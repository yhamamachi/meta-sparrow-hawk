FILES:${PN}:remove = "/usr/include/CL/cl_platform.h"

