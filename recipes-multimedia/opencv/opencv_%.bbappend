PACKAGECONFIG:append = " gtk"
